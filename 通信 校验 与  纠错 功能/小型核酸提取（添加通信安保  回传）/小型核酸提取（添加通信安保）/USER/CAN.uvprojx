# Keil uVision project CAN.uvprojx, settings and files
target CAN (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\CAN;..\HARDWARE\24CXX;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\PWM;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\HARDWARE\Moto;..\USMART;..\HARDWARE\Stringdeal;..\HARDWARE\Device;..\HARDWARE\DAC;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Moto/: moto.c
    ../HARDWARE/Stringdeal/: string_deal.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: 128S085.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dac.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group Device
    ../HARDWARE/Device/: DeviceVibration.c
